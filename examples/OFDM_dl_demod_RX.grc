options:
  parameters:
    author: Cyrille Morin
    generate_options: bokeh_gui
    id: dl_demod_RX
    output_language: python
    placement: (0,0,4,1)
    title: RL Demod training
  states: {}

blocks:
- name: ber
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    function_name: level
    poll_rate: '0.5'
    value: '0'
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: '4'
  states: {}
- name: bits_per_symbol_0
  id: variable
  parameters:
    value: len(occupied_carriers[0])
  states: {}
- name: errors
  id: variable_function_probe
  parameters:
    block_id: learning_ber_bf_0
    function_name: total_errors
    poll_rate: '0.5'
    value: '0'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: gain_rx
  id: variable_bokehgui_slider
  parameters:
    end: '90'
    label: Amplitude Rx
    start: '0'
    step: '0.5'
    throttle: '1'
    type: real
    value: '5'
  states: {}
- name: gain_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0:0,4,2,2
    label: Amplitude Rx
    start: '0'
    step: '.2'
    stop: '90'
    value: '5'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_ofdm(occupied_carriers, 1, length_tag_key,)
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=packet_length_tag_key, frame_len_tag_key=length_tag_key_0, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=8, scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: ip
  id: variable
  parameters:
    value: '"localhost"'
  states: {state: disabled}
- name: label_ber
  id: variable_bokehgui_label
  parameters:
    label: BER
    type: raw
    value: ber
  states: {}
- name: label_errors
  id: variable_bokehgui_label
  parameters:
    label: Error count
    type: int
    value: errors
  states: {}
- name: ldpc_dec
  id: variable_ldpc_decoder_def
  parameters:
    file: gr.prefix() + "/share/gnuradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"
    max_iter: '50'
    ndim: '0'
    sigma: '0.5'
  states: {}
- name: ldpc_enc
  id: variable_ldpc_encoder_def
  parameters:
    file: gr.prefix() + "/share/gnuradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"
    ndim: '0'
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: length_tag_key_0
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: mag
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0:2,0,2,4
    label: Eb/N0
    start: snr_start
    step: '0.1'
    stop: '40'
    value: '10'
  states: {state: disabled}
- name: mag
  id: variable_bokehgui_slider
  parameters:
    end: '40'
    label: Eb/N0
    start: '0'
    step: '0.1'
    throttle: '1'
    type: real
    value: '10'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-22, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 23)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '400'
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    value: '"packet_length"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_static(fft_len,  occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.qam_constellation(constellation_points=2**bits_per_symbol)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: puncpat
  id: variable
  parameters:
    value: '''11'''
  states: {}
- name: reset_ber_0
  id: variable_bokehgui_button
  parameters:
    block_id: learning_ber_bf_0
    function_args: ''
    function_name: reset_counters
    label: '"Reset BER last: {}".format(reset_ber)'
    type: real
    value: '0'
  states: {}
- name: reset_rx
  id: learning_button
  parameters:
    block_id: learning_dl_demod_0
    function_args: ''
    function_name: reset
    gui_hint: qtgui_tab_widget_0@0:5,1,1,1
    label: '&Reset RX model state'
    type: int
    value: '0'
  states: {state: disabled}
- name: reset_rx_0
  id: variable_bokehgui_button
  parameters:
    block_id: learning_dl_demod_0
    function_args: ''
    function_name: reset
    label: Reset RX model state
    type: int
    value: '0'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_lr
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0:10,4,1,2
    label: RX Learning rate (log)
    start: '-5'
    step: '0.1'
    stop: '0'
    value: '-2'
  states: {state: disabled}
- name: rx_lr
  id: variable_bokehgui_slider
  parameters:
    end: '0'
    label: RX Learning rate (log)
    start: '-5'
    step: '0.1'
    throttle: '1'
    type: real
    value: '-2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 0.55e6
  states: {}
- name: save
  id: learning_button
  parameters:
    block_id: learning_dl_demod_0
    function_args: ''
    function_name: save_model
    label: '&Save RX model'
    type: int
    value: '0'
  states: {state: disabled}
- name: snr_start
  id: variable
  parameters:
    value: '0'
  states: {}
- name: snr_step
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: snr_stop
  id: variable
  parameters:
    value: '29'
  states: {}
- name: start_button
  id: learning_button
  parameters:
    block_id: learning_sweeper_0
    function_args: ''
    function_name: start_sweep
    gui_hint: qtgui_tab_widget_0@0:8,0,1,1
    label: '&Start sweep'
    type: int
    value: '0'
  states: {state: disabled}
- name: start_button_0
  id: variable_bokehgui_button
  parameters:
    block_id: learning_sweeper_0
    function_args: ''
    function_name: start_sweep
    label: Start sweep
    type: int
    value: '0'
  states: {state: disabled}
- name: stop_button
  id: learning_button
  parameters:
    block_id: learning_sweeper_0
    function_args: ''
    function_name: stop_sweep
    gui_hint: qtgui_tab_widget_0@0:9, 0,1,1
    label: '&Stop sweep'
    type: int
    value: '0'
  states: {state: disabled}
- name: stop_button_0
  id: variable_bokehgui_button
  parameters:
    block_id: learning_sweeper_0
    function_args: ''
    function_name: stop_sweep
    label: Stop sweep
    type: int
    value: '0'
  states: {state: disabled}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: t_state
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab_widget_0@0:4,0,1,1
    label: Training
    label0: 'On'
    label1: 'Off'
    num_opts: '2'
    option0: '1'
    option1: '0'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {state: disabled}
- name: t_state
  id: variable_bokehgui_radiobutton
  parameters:
    inline: 'True'
    label0: 'On'
    label1: 'Off'
    label2: ''
    label3: ''
    label4: ''
    labels: '[]'
    num_opts: '2'
    option0: '1'
    option1: '0'
    option2: 'True'
    option3: '3'
    option4: '4'
    options: '[0, 1, 2]'
    type: int
    value: '1'
  states: {}
- name: timestamp
  id: variable_qtgui_entry
  parameters:
    label: Load timestamp
    type: string
    value: '1'
  states: {state: disabled}
- name: timestamp
  id: variable_bokehgui_textbox
  parameters:
    label: Load timestamp
    type: string
    value: '1'
  states: {}
- name: training_mod
  id: variable_qtgui_entry
  parameters:
    gui_hint: qtgui_tab_widget_0@0:4,1,1,1
    label: Alternate training every
    type: int
    value: '1'
  states: {state: disabled}
- name: training_mod
  id: variable_bokehgui_textbox
  parameters:
    label: Alternate training every
    type: int
    value: '1'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: len(occupied_carriers[0])
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: np.sqrt(10**(np.log10(1/bits_per_symbol)-(mag/10.0)))*1
    noise_type: analog.GR_GAUSSIAN
    seed: '-1'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_2_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_ctrlport_monitor_0
  id: blocks_ctrlport_monitor
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_len+0*(fft_len//4) + 10
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: bits_per_symbol
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: bits_per_symbol
    l: '1'
    len_tag_key: ''
  states: {}
- name: blocks_repack_bits_bb_0_0_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: bits_per_symbol
    l: '1'
    len_tag_key: ''
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0_1_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: bits_per_symbol
    l: '1'
    len_tag_key: ''
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/6
    type: byte
  states: {state: bypassed}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: bits_per_symbol
    type: float
  states: {state: disabled}
- name: bokehgui_frequency_sink_x_0
  id: bokehgui_frequency_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    average: '1.0'
    axislabels: 'True'
    bw: samp_rate
    color1: '"blue"'
    color2: '"red"'
    fc: freq
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    maxhold: 'True'
    name: '"Rx signal"'
    nconnections: '1'
    placement: (3,1,1,2)
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_level: '0.0'
    tr_mode: bokehgui.TRIG_MODE_FREE
    tr_tag: '""'
    type: complex
    update_time: '100'
    width1: '1'
    width2: '1'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    xlabel: Frequency
    xunit: '"Hz"'
    ylabel: Relative Gain
    ymax: '10'
    ymin: '-140'
    yunit: dB
  states: {state: disabled}
- name: bokehgui_time_const_x_0
  id: bokehgui_time_const_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    entags: 'False'
    grid: 'True'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: '''o'''
    marker2: '''o'''
    name: '"Received noisy constellation"'
    nconnections: '1'
    placement: (0,1,2,2)
    size: '1024'
    srate: samp_rate
    style2: ''
    tr_chan: '0'
    tr_delay: '0'
    tr_level: '0.0'
    tr_mode: bokehgui.TRIG_MODE_FREE
    tr_slope: bokehgui.TRIG_SLOPE_POS
    tr_tag: '""'
    type: complex
    update_time: '500'
    width1: '1'
    width2: '1'
    xlabel: I Channel
    xmax: '2'
    xmin: '-2'
    xunit: '""'
    ylabel: Q Channel
    ymax: '2'
    ymin: '-2'
    yunit: '""'
  states: {}
- name: bokehgui_time_sink_x_0
  id: bokehgui_time_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    entags: 'True'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    name: '"Decoded minus label"'
    nconnections: '1'
    placement: (2,1,1,2)
    size: '1024'
    srate: samp_rate
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_delay: '0'
    tr_level: '0.0'
    tr_mode: bokehgui.TRIG_MODE_FREE
    tr_slope: bokehgui.TRIG_SLOPE_POS
    tr_tag: '""'
    type: float
    update_time: '500'
    width1: '1'
    width2: '1'
    xlabel: Symbol
    xlog: 'False'
    xunit: '""'
    ylabel: Difference
    ylog: 'False'
    ymax: '100'
    ymin: '-100'
    yunit: '""'
  states: {}
- name: bokehgui_vector_sink_x_0
  id: bokehgui_vector_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    alpha3: '1.0'
    alpha4: '1.0'
    average: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    color3: '"green"'
    color4: '"black"'
    grid: 'True'
    label1: Learned
    label2: QPSK
    label3: ''
    label4: ''
    legend: 'True'
    marker1: None
    marker2: None
    marker3: None
    marker4: None
    name: '"Performance curve"'
    nconnections: '2'
    placement: (4,1,2,2)
    style1: '"solid"'
    style2: '"solid"'
    style3: '"solid"'
    style4: '"solid"'
    type: float
    update_time: '100'
    vec_len: len(np.arange(snr_start,snr_stop,snr_step))
    width1: '1'
    width2: '1'
    width3: '1'
    width4: '1'
    x_values: np.arange(snr_start,snr_stop,snr_step)
    xlabel: Eb/N0
    xunit: '"dB"'
    ylabel: BER
    ymax: '0'
    ymin: '-6'
    yunit: log
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {state: disabled}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: fft_len//4
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: length_tag_key_0
    output_symbols: 'True'
    samp_rate: int(samp_rate)
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {state: disabled}
- name: digital_map_bb_0_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {state: disabled}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key_0
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: length_tag_key_0
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_header
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key_0
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_payload
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key_0
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class alignement(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Align two stream according to a packet number set in a tag"""

          def __init__(self, tag_name="packet_num", frame_size=384, vector_size=1, user_symbols=1):

              gr.basic_block.__init__(self,
                  name="Align Embedded",
                  in_sig=[(np.complex64, vector_size), np.int8],
                  out_sig=[(np.complex64, vector_size), np.int8])
              self.frame_size = frame_size
              self.vector_size = vector_size
              self.user_symbols = user_symbols
              self.tag_name = tag_name
              self.previous_packet = -1
              self.last_packet_loss = -1
              self.set_tag_propagation_policy(0)
              self.set_output_multiple(self.frame_size)

          def forecast(self, noutput_items, ninput_items_required):
              # setup size of input_items[i] for work call
              ninput_items_required[0] = self.frame_size //self.user_symbols
              ninput_items_required[1] = self.frame_size


          def general_work(self, input_items, output_items):
              if  len(input_items[0]) < self.frame_size// self.user_symbols: #Just in case
                  print("Err input size: ", len(input_items[0]), " ", len(input_items[1]))
                  return 0

              read0 = self.nitems_read(0)
              read1 = self.nitems_read(1)
              in0 = input_items[0]
              in1 = input_items[1]
              out0 = output_items[0]
              out1 = output_items[1]
              tags_0 = self.get_tags_in_window(0, 0, len(in0), pmt.intern(self.tag_name))
              tags_1 = self.get_tags_in_window(1, 0, len(in1), pmt.intern(self.tag_name))
              value0 = 0
              value1 = -1
              offset0 = 0
              offset1 = 0

              # print("function called: in0: {} in1: {}".format(len(in0), len(in1)))
              if len(tags_0) == 0:
                  print("We don't have any tag in stream 0")
                  self.consume(0, len(in0))
                  return 0
              if len(tags_1) == 0:
                  print("We don't have any tag in stream 1")
                  self.consume(1, len(in1))
                  return 0

              # if len(tags_0) > 1:
              #     print("Tag interval for input0 {}".format(tags_0[1].offset - tags_0[0].offset))
              # if len(tags_1) > 1:
              #     print("Tag interval for input1 {}".format(tags_1[1].offset - tags_1[0].offset))

              #Find the tag in each input that has the same value as the other and is the lowest possible. We assume that the values are increasing
              for tag0 in tags_0:
                  value0 = pmt.to_python(tag0.value)

                  for tag1 in tags_1:
                      value1 = pmt.to_python(tag1.value)
                      offset1 = tag1.offset

                      if value0 <= value1:
                          break
                      if value0 > value1:
                          continue
                  if value0 == value1:
                      offset0 = tag0.offset
                      break
                  if value0 < value1:
                      continue

              if value0 != value1:
                  print("Cannot make correspondance between the two streams.", value0, value1)
                  if value0 > value1:
                      self.consume(1, len(in1))
                  if value0 < value1:
                      self.consume(0, len(in0))
                  return 0

              #Index of the selected tags relative to the input arays
              position0 = offset0 - read0
              position1 = offset1 - read1

              #We process a frame only if it has been fully received
              if position0 + (self.frame_size//self.user_symbols) >= len(in0):
                  # print("Stream 0 too late, consuming")
                  self.consume(0, position0)
                  return 0
              if position1 + self.frame_size >= len(in1):
                  print("Stream 1 too late, consuming")
                  self.consume(1, position1)
                  return 0

              #Detect packet packet loss
              if value0 != self.previous_packet+1:
                  # for i in range(self.previous_packet+1, value0):
                  print("Packet lost: {} in a row. Value is: {} Packets since last loss: {}".format(value0-(self.previous_packet+1), value0, value0-self.last_packet_loss))
                  self.last_packet_loss = value0
                      # self.message_port_pub(pmt.intern("error"), pmt.to_pmt(self.packet_loss_penalty))
              if len(out0) < self.frame_size:
                  print("output size 0 not big enough")
              if len(out1) < self.frame_size:
                  print("output size 1 not big enough")
              out0[:self.frame_size//self.user_symbols] = in0[position0:position0 + (self.frame_size//self.user_symbols)]
              out1[:self.frame_size] = in1[position1:position1 + self.frame_size]
              # print("Align: {} items difference between output streams".format(self.nitems_written(0) - self.nitems_written(1)))
              self.add_item_tag(0, self.nitems_written(0) , pmt.intern(self.tag_name), pmt.to_pmt(value0))
              # print("outputting packet num: {}".format(value0))
              # diff = in0[position0:position0 + self.frame_size] - in1[position1:position1 + self.frame_size]
              # norm = numpy.linalg.norm(diff, ord = 2)

              # self.message_port_pub(pmt.intern("error"), pmt.to_pmt(norm.item()))
              # print(norm, value0)

              self.previous_packet = value0
              self.consume(0, position0 + (self.frame_size//self.user_symbols))
              self.consume(1, position1 + self.frame_size)
              self.produce(0, (self.frame_size//self.user_symbols))
              self.produce(1, self.frame_size)

              return 0
    frame_size: packet_len
    tag_name: '"packet_num"'
    user_symbols: '1'
    vector_size: '1'
  states: {state: disabled}
- name: fec_extended_decoder_0_1_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec_0
    puncpat: puncpat
    threadtype: none
  states: {state: disabled}
- name: fec_extended_decoder_0_1_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec
    puncpat: puncpat
    threadtype: none
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(freq)
    gain1: '''manual'''
    manual_gain1: gain_rx
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    uri: '''ip:pluto.local'''
  states: {state: disabled}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.digital.utils import tagged_streams
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: ip
  id: parameter
  parameters:
    label: IP
    short_id: i
    type: str
    value: localhost
  states: {}
- name: learning_align_0
  id: learning_align
  parameters:
    frame_size: packet_len
    label_frame_size: '400'
    tag_name: packet_num
    user_symbols: '48'
    vec_len: '1'
  states: {}
- name: learning_ber_bf_0
  id: learning_ber_bf
  parameters:
    ber_limit: '-7.0'
    berminerrors: '100'
    bitsperbyte: '1'
    test_mode: 'False'
  states: {}
- name: learning_dl_demod_0
  id: learning_dl_demod
  parameters:
    batch_size: '20'
    bitspmsg: bits_per_symbol
    bitwise: 'False'
    file: timestamp
    folder: /home/cyrille/Gnu-Radio/modules/gr-learning/examples/saved_models
    lr: '10**rx_lr '
    packet_len: packet_len
    tag_name: packet_num
    training_mod: training_mod
    tstate: t_state
  states: {}
- name: learning_sweeper_0
  id: learning_sweeper
  parameters:
    ber_id_1: ''
    ber_id_2: ''
    error_threshold: '200'
    errors: errors
    probe_id_1: ''
    probe_id_2: ''
    snr_var: mag
    snrs: np.arange(snr_start,snr_stop,snr_step)
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0:6,0,2,2
    name: '"Received noisy constellation"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: FFT Plot
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: qtgui_tab_widget_0@0:4,4,2,2
    max: '100'
    min: '0'
    name: '"BER"'
    type: float
  states: {state: disabled}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Mainoutput
    label1: Debug
    num_tabs: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@0:6,2,2,2
    label1: Scope Plot
    name: Scope Plot
    size: '1024'
    srate: samp_rate
    tr_tag: '"packet_num"'
    type: float
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0:8,2,3,2
    label1: Measure
    label2: QPSK
    name: '"BER Curve"'
    nconnections: '2'
    vlen: len(np.arange(snr_start,snr_stop,snr_step))
    x_axis_label: '"Eb/N0"'
    x_start: snr_start
    x_step: snr_step
    y_axis_label: '"BER (log)"'
    ymax: '0'
    ymin: '-6'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain_rx
    iq_imbal_enb0: '""'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Transmitted bits
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:50002
    timeout: '1000'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://"+ip+":50000"'
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_msg_source_0_0
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://"+ip+":50001"'
    timeout: '1000'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', bokehgui_time_const_x_0, '0']
- [blocks_add_xx_0, '0', epy_block_0, '0']
- [blocks_add_xx_0, '0', learning_align_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_char_to_float_0_2_0, '0', fec_extended_decoder_0_1_0_0, '0']
- [blocks_char_to_float_0_2_0_0, '0', fec_extended_decoder_0_1_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_throttle_0, '0']
- [blocks_repack_bits_bb_0_0_1, '0', digital_map_bb_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_1, '0', learning_ber_bf_0, '1']
- [blocks_repack_bits_bb_0_0_1_0, '0', digital_map_bb_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_1_1, '0', learning_ber_bf_0, '0']
- [blocks_sub_xx_0, '0', bokehgui_time_sink_x_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', learning_align_0, '1']
- [blocks_throttle_0_0_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0_0_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [blocks_vector_to_stream_1, '0', fec_extended_decoder_0_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_constellation_decoder_cb_1, '0', blocks_char_to_float_0_0, '0']
- [digital_constellation_decoder_cb_1, '0', blocks_repack_bits_bb_0_0_1_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_0, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_1, '0']
- [digital_map_bb_0_0_0_0, '0', blocks_char_to_float_0_2_0, '0']
- [digital_map_bb_0_0_0_0_0, '0', blocks_char_to_float_0_2_0_0, '0']
- [digital_ofdm_chanest_vcvc_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_header, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', digital_ofdm_serializer_vcc_payload, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_constellation_decoder_cb_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', virtual_sink_1_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [digital_packet_headerparser_b_0, header_data, digital_header_payload_demux_0, header_data]
- [fec_extended_decoder_0_1_0, '0', learning_ber_bf_0, '0']
- [fec_extended_decoder_0_1_0_0, '0', learning_ber_bf_0, '1']
- [fft_vxx_0, '0', digital_ofdm_chanest_vcvc_0, '0']
- [fft_vxx_1, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- [iio_pluto_source_0, '0', blocks_delay_0, '0']
- [iio_pluto_source_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [learning_align_0, '0', digital_constellation_decoder_cb_1, '0']
- [learning_align_0, '0', learning_dl_demod_0, '0']
- [learning_align_0, '1', learning_dl_demod_0, '1']
- [learning_ber_bf_0, '0', blocks_probe_signal_x_0, '0']
- [learning_ber_bf_0, '0', qtgui_number_sink_1_0, '0']
- [learning_dl_demod_0, '0', blocks_null_sink_0, '0']
- [learning_dl_demod_0, '0', blocks_vector_to_stream_1, '0']
- [learning_dl_demod_0, '1', blocks_char_to_float_0_0, '0']
- [learning_dl_demod_0, '1', blocks_repack_bits_bb_0_0_1_1, '0']
- [learning_dl_demod_0, '2', blocks_char_to_float_0_0_0, '0']
- [learning_dl_demod_0, '2', blocks_repack_bits_bb_0_0_1, '0']
- [learning_dl_demod_0, losses, zeromq_pub_msg_sink_0_0_0, in]
- [learning_sweeper_0, '0', bokehgui_vector_sink_x_0, '0']
- [learning_sweeper_0, '0', qtgui_vector_sink_f_0_0, '0']
- [learning_sweeper_0, '1', bokehgui_vector_sink_x_0, '1']
- [learning_sweeper_0, '1', qtgui_vector_sink_f_0_0, '1']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', bokehgui_frequency_sink_x_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', fft_vxx_0, '0']
- [virtual_source_0_0, '0', blocks_add_xx_0, '0']
- [virtual_source_1, '0', fft_vxx_1, '0']
- [virtual_source_1_0, '0', blocks_throttle_0, '0']
- [zeromq_sub_msg_source_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [zeromq_sub_msg_source_0_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]

metadata:
  file_format: 1
