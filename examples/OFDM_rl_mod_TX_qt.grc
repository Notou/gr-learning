options:
  parameters:
    author: Cyrille Morin
    generate_options: qt_gui
    id: rl_mod_TX
    output_language: python
    placement: (0,0,2,1)
    title: RL Mod training
  states: {}

blocks:
- name: bits_per_symbol
  id: variable
  parameters:
    value: '4'
  states: {}
- name: bits_per_symbol_0
  id: variable
  parameters:
    value: len(occupied_carriers[0])
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,2,2
    label: Amplitude
    start: '0'
    step: '.2'
    stop: '90'
    value: '10'
  states: {}
- name: gain
  id: variable_bokehgui_slider
  parameters:
    end: '90'
    label: Amplitude
    start: '0'
    step: '0.5'
    throttle: '1'
    type: real
    value: '10'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_ofdm(occupied_carriers, 1, length_tag_key,)
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=packet_length_tag_key, frame_len_tag_key=length_tag_key_0, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=8, scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: ldpc_enc
  id: variable_ldpc_encoder_def
  parameters:
    file: gr.prefix() + "/share/gnuradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"
    ndim: '0'
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: length_tag_key_0
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-22, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 23)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '400'
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    value: '"packet_length"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_static(fft_len,  occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.qam_constellation(constellation_points=2**bits_per_symbol,differential=False,mod_code=digital.utils.mod_codes.GRAY_CODE)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: puncpat
  id: variable
  parameters:
    value: '''11'''
  states: {}
- name: reset_tx
  id: learning_button
  parameters:
    block_id: learning_rl_mod_0
    function_args: ''
    function_name: reset
    gui_hint: 5,0,1,1
    label: '&Reset TX model state'
    type: int
    value: '0'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 0.3e6
  states: {}
- name: save_0
  id: learning_button
  parameters:
    block_id: learning_rl_mod_0
    function_args: ''
    function_name: save_model
    label: '&Save TX model'
    type: int
    value: '0'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: t_state
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,0,1,1
    label: Training
    label0: 'On'
    label1: 'Off'
    num_opts: '2'
    option0: '1'
    option1: '0'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: t_state
  id: variable_bokehgui_radiobutton
  parameters:
    inline: 'True'
    label0: 'On'
    label1: 'Off'
    label2: ''
    label3: ''
    label4: ''
    labels: '[]'
    num_opts: '2'
    option0: '1'
    option1: '0'
    option2: 'True'
    option3: '3'
    option4: '4'
    options: '[0, 1, 2]'
    type: int
    value: '1'
  states: {state: disabled}
- name: timestamp
  id: variable_qtgui_entry
  parameters:
    label: Load timestamp
    type: string
    value: '1'
  states: {}
- name: timestamp
  id: variable_bokehgui_textbox
  parameters:
    label: Load timestamp
    type: string
    value: '1'
  states: {state: disabled}
- name: training_mod
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,1,1,1
    label: Alternate training every
    type: int
    value: '1'
  states: {}
- name: training_mod
  id: variable_bokehgui_textbox
  parameters:
    label: Alternate training every
    type: int
    value: '1'
  states: {state: disabled}
- name: tx_explo
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,0,1,2
    label: TX Exploration noise
    start: '0.001'
    step: '0.001'
    stop: '0.5'
    value: '0.15'
  states: {}
- name: tx_explo
  id: variable_bokehgui_slider
  parameters:
    end: '0.5'
    label: TX Exploration noise
    start: '0.001'
    step: '0.001'
    throttle: '1'
    type: real
    value: '0.15'
  states: {state: disabled}
- name: tx_lr
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,0,1,2
    label: TX Learning rate (log)
    start: '-5'
    step: '0.1'
    stop: '0'
    value: '-3'
  states: {}
- name: tx_lr
  id: variable_bokehgui_slider
  parameters:
    end: '0'
    label: TX Learning rate (log)
    start: '-5'
    step: '0.1'
    throttle: '1'
    type: real
    value: '-3'
  states: {state: disabled}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_ctrlport_monitor_0
  id: blocks_ctrlport_monitor
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.01'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: 2**bits_per_symbol
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: bits_per_symbol
    len_tag_key: ''
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: length_tag_key
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '2000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: length_tag_key
    ninputs: '3'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: length_tag_key
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_1
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/6
    type: byte
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: 2**bits_per_symbol
    type: complex
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: length_tag_key
  states: {}
- name: fec_extended_encoder_1_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc
    puncpat: puncpat
    threadtype: none
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: gain
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(freq)
    samplerate: int(samp_rate)
    uri: '''ip:pluto.local'''
  states: {state: disabled}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.digital.utils import tagged_streams
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: ip
  id: parameter
  parameters:
    label: IP
    short_id: i
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: learning_rl_mod_0
  id: learning_rl_mod
  parameters:
    batch_size: '1'
    bitspmsg: bits_per_symbol
    explo_noise: tx_explo
    file: timestamp
    folder: /home/cyrille/Gnu-Radio/modules/gr-learning/examples/saved_models
    lr: '10**tx_lr '
    packet_len: packet_len
    state: 't_state '
    tag_name: packet_num
    training_mod: training_mod
  states: {}
- name: learning_tag_numerotation_0
  id: learning_tag_numerotation
  parameters:
    interval: packet_len
    modulo: '4096'
    tag_name: packet_num
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 6,0,2,2
    label1: Classical
    label2: Learned
    name: '"Transmitted noiseless constellation"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    color3: '"red"'
    color4: '"red"'
    color5: '"red"'
    color6: '"red"'
    color7: '"red"'
    color8: '"red"'
    grid: 'True'
    gui_hint: 6,0,2,2
    label1: '000'
    label2: '001'
    label3: '010'
    label4: '011'
    label5: '100'
    label6: '101'
    label7: '110'
    label8: '111'
    marker4: '1'
    name: '"Transmitted noiseless constellation"'
    nconnections: 2**bits_per_symbol//2
    size: '1'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    color2: '"blue"'
    color3: '"red"'
    color4: '"red"'
    color5: '"red"'
    color6: '"red"'
    color7: '"green"'
    color8: '"red"'
    grid: 'True'
    gui_hint: 6,2,2,2
    label1: '000'
    label2: '001'
    label3: '010'
    label4: '011'
    label5: '100'
    label6: '101'
    label7: '110'
    label8: '111'
    marker4: '1'
    name: '"Transmitted noiseless constellation bit4=1"'
    nconnections: 2**bits_per_symbol//2
    size: '1'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_args: '""'
    gain0: gain
    len_tag_name: length_tag_key
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Transmitted bits
  states: {state: disabled}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:50000
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:50001
    timeout: '1000'
  states: {}
- name: zeromq_sub_msg_source_0_1
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://"+ip+":50002"'
    timeout: '1000'
  states: {}

connections:
- [analog_random_source_x_0_0, '0', fec_extended_encoder_1_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_tagged_stream_mux_1, '1']
- [blocks_multiply_const_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_null_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_1, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0_0, '1']
- [blocks_stream_to_tagged_stream_0_0, '0', learning_tag_numerotation_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_tagged_stream_mux_0_0_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_1, '0', blocks_throttle_0_0_0, '0']
- [blocks_tagged_stream_mux_1, '0', iio_pluto_sink_0, '0']
- [blocks_tagged_stream_to_pdu_0_0, pdus, zeromq_pub_msg_sink_0, in]
- [blocks_tagged_stream_to_pdu_0_0_0, pdus, zeromq_pub_msg_sink_0_0, in]
- [blocks_throttle_0, '0', blocks_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [digital_chunks_to_symbols_xx_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_xx_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [fec_extended_encoder_1_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [fft_vxx_0_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [learning_rl_mod_0, '0', blocks_tagged_stream_mux_0_0, '2']
- [learning_rl_mod_0, '1', qtgui_const_sink_x_0_0_0, '1']
- [learning_rl_mod_0, '2', blocks_null_sink_0, '0']
- [learning_tag_numerotation_0, '0', blocks_throttle_0, '0']
- [learning_tag_numerotation_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [learning_tag_numerotation_0, '0', learning_rl_mod_0, '0']
- [virtual_source_0_0_0_1, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [zeromq_sub_msg_source_0_1, out, learning_rl_mod_0, losses]

metadata:
  file_format: 1
